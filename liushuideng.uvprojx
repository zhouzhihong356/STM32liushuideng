# Keil uVision project liushuideng.uvprojx, settings and files
target RunningLED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x8000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RunningLED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CORE;.\USER;.\STM32F10x_FWLib\inc;.\HARDWARE\LED;.\HARDWARE\KEY;.\HARDWARE\DELAY
  asm define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group CORE
    ./CORE/: startup_stm32f10x_md.s system_stm32f10x.c stm32f10x.h system_stm32f10x.h
  group HARDWARE
    ./HARDWARE/LED/: led.c led.h
    ./HARDWARE/KEY/: key.c key.h
    ./HARDWARE/DELAY/: delay.c delay.h
  group FWLIB
    ./STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c
